# Keil uVision project UCOSII-1.uvprojx, settings and files
target WK_JZQ (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UCOSII-1 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LIGHT;..\HARDWARE\RELAY;..\HARDWARE\RF;..\HARDWARE\STMFLASH;..\HARDWARE\W5500;..\MY_CORE;..\HARDWARE\MALLOC;..\HARDWARE\BEEP;..\HARDWARE\SD_CARD;..\MY_OS;..\SOFTWARE\CRC8_16;..\SOFTWARE\JSON;..\SOFTWARE\FILE;..\SOFTWARE\DATA_MAP;..\HARDWARE\W25QXX;..\SOFTWARE\DHCP;..\SOFTWARE\ENTERNET;..\SOFTWARE\WK_JSON;..\SOFTWARE\DATA_TYPE;..\SOFTWARE\POWER;..\SOFTWARE\DNS;..\MQTT\mqttsrc;..\SOFTWARE\BAIDU_IOT;..\SOFTWARE\TIMER;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8002800 size 0x38000
  memory RVCT9: RAM 0x20000004 size 0x27fc
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: LCD.c
    ../HARDWARE/LIGHT/: light.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/RF/: rf.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/W5500/: W5500.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/SD_CARD/: fats.c MMC_SD.C spi.c
    ../HARDWARE/W25QXX/: flash.c
  group SOFTWARE
    ../SOFTWARE/CRC8_16/: crc8_16.c
    ../SOFTWARE/JSON/: cJSON.c
    ../SOFTWARE/FILE/: file.c
    ../SOFTWARE/DATA_MAP/: data_map.c
    ../SOFTWARE/DHCP/: dhcp.c
    ../SOFTWARE/ENTERNET/: enternet.c
    ../SOFTWARE/WK_JSON/: wk_json.c
    ../SOFTWARE/DATA_TYPE/: data_type.c
    ../SOFTWARE/POWER/: power.c
    ../SOFTWARE/DNS/: dns.c
    ../SOFTWARE/BAIDU_IOT/: baidu_iot.c
    ../SOFTWARE/TIMER/: timer.c
  group OS_CORE
    ../UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group OS_CONFIG
    ../UCOSII/CONFIG/: includes.h
  group MY_OS
    ../MY_OS/: os_msg.c os_task.c os_mem.c os_sys.c os_fats.c
  group MY_TASK
    ../MY_CORE/: my_key.c my_lcd.c my_light.c my_cfg.c my_rf.c my_w5500.c my_messeg.c my_autocontrol.c my_debug.c my_iot.c my_lcd_new.c my_rf_new.c my_light_new.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_exti.c
  group README
    ../: ReadMe.txt
  group MQTT
    ../MQTT/mqttsrc/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
